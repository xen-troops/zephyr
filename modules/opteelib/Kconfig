## modules/opteelib/Kconfig
```kconfig
# Copyright (c) 2026 EPAM Systems
# SPDX-License-Identifier: Apache-2.0

config ZEPHYR_OPTEELIB_MODULE
	bool
```
